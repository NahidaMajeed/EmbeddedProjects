# Keil uVision project DoorLock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DoorLock +hex
  c flags: SizeSpeed=1
  c include: ..\include
  group Source Group 1
    ./: STARTUP.A51
    ../src/: delay.c lcd.c mkeys.c stepper.c
    ../app/: main.c
    ../include/: delay.h global.h lcd.h mkeys.h stepper.h
