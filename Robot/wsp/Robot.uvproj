# Keil uVision project Robot.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Robot +hex
  c flags: SizeSpeed=1
  c include: ..\include
  group Source Group 1
    ./: STARTUP.A51
    ../app/: main.c
    ../include/: global.h robot.h
    ../src/: robot.c
