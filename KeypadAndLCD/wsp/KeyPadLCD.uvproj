# Keil uVision project KeyPadLCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: KeyPadLCD +hex
  c flags: SizeSpeed=1
  c include: ..\include
  asm include: ..\include
  group Source Group 1
    ./: STARTUP.A51
    ../src/: delay.c lcd.c mkeys.c
    ../app/: main.c
